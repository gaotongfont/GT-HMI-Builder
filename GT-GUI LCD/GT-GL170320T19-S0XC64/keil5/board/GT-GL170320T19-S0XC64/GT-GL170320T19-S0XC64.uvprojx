# Keil uVision project GT-GL170320T19-S0XC64.uvprojx, settings and files
target AT32_App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gui_lcd_mcu
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: AT32F437VGT7;USE_STDPERIPH_DRIVER;GT_HMI_BOARD_CONFIG_VERTICAL=0
  c misc: --locale=english
  c include: .\APP;.\bsp;.\GT-HMI-Engine;.\GT-HMI-Engine\driver;.\GT-HMI-Engine\src;.\GT-HMI-Engine\src\core;.\GT-HMI-Engine\src\extra;.\GT-HMI-Engine\src\extra\draw;.\GT-HMI-Engine\src\extra\gif;.\GT-HMI-Engine\src\extra\jpeg;.\GT-HMI-Engine\src\extra\png;.\GT-HMI-Engine\src\font;.\GT-HMI-Engine\src\hal;.\GT-HMI-Engine\src\others;.\GT-HMI-Engine\src\utils;.\GT-HMI-Engine\src\widgets;.\libraries\cmsis\cm4\core_support;.\libraries\cmsis\cm4\device_support;.\libraries\cmsis\dsp\ComputeLibrary\Include;.\libraries\cmsis\dsp\include;.\libraries\cmsis\dsp\PrivateInclude;.\libraries\cmsis\dsp\Source\DistanceFunctions;.\libraries\drivers\inc;.\ui
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group APP
    ./APP/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ./bsp/: bsp_delay.c bsp_iic_io.c bsp_lcd_xmc.c bsp_led.c bsp_qspi_flash.c bsp_uart.c bsp_wdt.c touch.c touch_bl6133.c touch_cst836u.c
  group GT-HMI-Engine/driver
    ./GT-HMI-Engine/driver/: gt_gui_driver.lib gt_port_disp.c gt_port_indev.c gt_port_src.c gt_port_vf.c
  group GT-HMI-Engine/src/core
    ./GT-HMI-Engine/src/core/: gt_disp.c gt_draw.c gt_event.c gt_fs.c gt_graph_base.c gt_handler.c gt_img_decoder.c gt_indev.c gt_layout.c gt_mem.c gt_obj_pos.c gt_obj_scroll.c gt_refr.c gt_scr_stack.c gt_style.c gt_timer.c
  group GT-HMI-Engine/src/extra
    ./GT-HMI-Engine/src/extra/: gt_extra.c
  group GT-HMI-Engine/src/extra/draw
    ./GT-HMI-Engine/src/extra/draw/: gt_draw_blend.c gt_draw_blend_with_argb888.c gt_draw_blend_with_rgb565.c gt_draw_blend_with_rgb888.c
  group GT-HMI-Engine/src/extra/gif
    ./GT-HMI-Engine/src/extra/gif/: gifdec.c
  group GT-HMI-Engine/src/extra/jpeg
    ./GT-HMI-Engine/src/extra/jpeg/: gt_sjpg.c tjpgd.c
  group GT-HMI-Engine/src/extra/png
    ./GT-HMI-Engine/src/extra/png/: gt_png.c lodepng.c
  group GT-HMI-Engine/src/font
    ./GT-HMI-Engine/src/font/: gt_font.c gt_symbol.c
  group GT-HMI-Engine/src/hal
    ./GT-HMI-Engine/src/hal/: gt_hal_disp.c gt_hal_file_header.c gt_hal_fs.c gt_hal_indev.c gt_hal_src.c gt_hal_tick.c gt_hal_vf.c
  group GT-HMI-Engine/src/others
    ./GT-HMI-Engine/src/others/: gt_anim.c gt_area.c gt_color.c gt_effects.c gt_gc.c gt_ll.c gt_math.c gt_tlsf.c gt_txt.c
  group GT-HMI-Engine/src/utils
    ./GT-HMI-Engine/src/utils/: gt_stack.c gt_vector.c
  group GT-HMI-Engine/src/widgets
    ./GT-HMI-Engine/src/widgets/: gt_barcode.c gt_btn.c gt_btnmap.c gt_chat.c gt_checkbox.c gt_clock.c gt_dialog.c gt_gif.c gt_group.c gt_img.c gt_imgbtn.c gt_input.c gt_input_number.c gt_keypad.c gt_label.c gt_line.c gt_listview.c gt_obj.c gt_obj_class.c gt_option.c gt_player.c gt_progress_bar.c gt_qrcode.c gt_radio.c gt_rect.c gt_roller.c gt_slider.c gt_status_bar.c gt_switch.c gt_template.c gt_textarea.c gt_view_pager.c gt_wordart.c
  group libraries/cmsis/cm4/device_support
    ./libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ./libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group libraries/drivers/src
    ./libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group ui
    ./ui/: gt_init_screen_1.c gt_init_screen_10.c gt_init_screen_11.c gt_init_screen_12.c gt_init_screen_13.c gt_init_screen_2.c gt_init_screen_3.c gt_init_screen_4.c gt_init_screen_5.c gt_init_screen_6.c gt_init_screen_7.c gt_init_screen_8.c gt_init_screen_9.c gt_init_screen_home.c gt_ui.c
