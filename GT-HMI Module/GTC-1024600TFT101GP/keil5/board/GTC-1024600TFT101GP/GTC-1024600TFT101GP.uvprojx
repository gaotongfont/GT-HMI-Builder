# Keil uVision project GTC-1024600TFT101GP.uvprojx, settings and files
target SWM341 (6140000::V6.14::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.20.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: hmi_mod_mcu
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=4 v6LangP=1 wLevel=1
  c define: GT_HMI_BOARD_CONFIG_VERTICAL=0
  c misc: -mthumb
  c include: .\BSP;.\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\CMSIS\DSP_Inc;.\CSL\CMSIS\DSP_Src\DistanceFunctions;.\CSL\SWM341_StdPeriph_Driver;.\CSL\SWM341_UsbHost_Lib;.\CSL\SWM341_UsbHost_Lib\CDC;.\CSL\SWM341_UsbHost_Lib\HID;.\CSL\SWM341_UsbHost_Lib\MSC;.\CSL\SWM341_UsbHost_Lib\MTP;.\GT-HMI-Engine;.\GT-HMI-Engine\driver;.\GT-HMI-Engine\src;.\GT-HMI-Engine\src\core;.\GT-HMI-Engine\src\extra;.\GT-HMI-Engine\src\extra\draw;.\GT-HMI-Engine\src\extra\gif;.\GT-HMI-Engine\src\extra\jpeg;.\GT-HMI-Engine\src\extra\png;.\GT-HMI-Engine\src\font;.\GT-HMI-Engine\src\hal;.\GT-HMI-Engine\src\others;.\GT-HMI-Engine\src\utils;.\GT-HMI-Engine\src\widgets;.\ui
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c
  group BSP
    ./BSP/: bsp_lcd_rgb.c bsp_led.c bsp_sfc.c bsp_uart.c dev_dac.c dev_sdio.c dev_sdram.c dev_systick.c dev_touch.c gt911.c
  group CSL/CMSIS/DeviceSupport
    ./CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group CSL/SWM341_StdPeriph_Driver
    ./CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_can.c SWM341_cordic.c SWM341_crc.c SWM341_dac.c SWM341_div.c SWM341_dma.c SWM341_dma2d.c SWM341_exti.c SWM341_flash.c SWM341_gpio.c SWM341_i2c.c SWM341_iofilt.c SWM341_jpeg.c SWM341_lcd.c SWM341_port.c SWM341_pwm.c SWM341_qei.c SWM341_rtc.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_spi.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_usbh.c SWM341_wdt.c
  group GT-HMI-Engine/driver
    ./GT-HMI-Engine/driver/: gt_gui_driver.lib gt_port_disp.c gt_port_indev.c gt_port_src.c gt_port_vf.c
  group GT-HMI-Engine/src/core
    ./GT-HMI-Engine/src/core/: gt_disp.c gt_draw.c gt_event.c gt_fs.c gt_graph_base.c gt_handler.c gt_img_decoder.c gt_indev.c gt_layout.c gt_mem.c gt_obj_pos.c gt_obj_scroll.c gt_refr.c gt_scr_stack.c gt_style.c gt_timer.c
  group GT-HMI-Engine/src/extra
    ./GT-HMI-Engine/src/extra/: gt_extra.c
  group GT-HMI-Engine/src/extra/draw
    ./GT-HMI-Engine/src/extra/draw/: gt_draw_blend.c gt_draw_blend_with_argb888.c gt_draw_blend_with_rgb565.c gt_draw_blend_with_rgb888.c
  group GT-HMI-Engine/src/extra/gif
    ./GT-HMI-Engine/src/extra/gif/: gifdec.c
  group GT-HMI-Engine/src/extra/jpeg
    ./GT-HMI-Engine/src/extra/jpeg/: gt_sjpg.c tjpgd.c
  group GT-HMI-Engine/src/extra/png
    ./GT-HMI-Engine/src/extra/png/: gt_png.c lodepng.c
  group GT-HMI-Engine/src/font
    ./GT-HMI-Engine/src/font/: gt_font.c gt_symbol.c
  group GT-HMI-Engine/src/hal
    ./GT-HMI-Engine/src/hal/: gt_hal_disp.c gt_hal_file_header.c gt_hal_fs.c gt_hal_indev.c gt_hal_src.c gt_hal_tick.c gt_hal_vf.c
  group GT-HMI-Engine/src/others
    ./GT-HMI-Engine/src/others/: gt_anim.c gt_area.c gt_color.c gt_effects.c gt_gc.c gt_ll.c gt_math.c gt_tlsf.c gt_txt.c
  group GT-HMI-Engine/src/utils
    ./GT-HMI-Engine/src/utils/: gt_stack.c gt_vector.c
  group GT-HMI-Engine/src/widgets
    ./GT-HMI-Engine/src/widgets/: gt_barcode.c gt_btn.c gt_btnmap.c gt_chat.c gt_checkbox.c gt_clock.c gt_dialog.c gt_gif.c gt_group.c gt_img.c gt_imgbtn.c gt_input.c gt_input_number.c gt_keypad.c gt_label.c gt_line.c gt_listview.c gt_obj.c gt_obj_class.c gt_option.c gt_player.c gt_progress_bar.c gt_qrcode.c gt_radio.c gt_rect.c gt_roller.c gt_slider.c gt_status_bar.c gt_switch.c gt_template.c gt_textarea.c gt_view_pager.c gt_wordart.c
  group ui
    ./ui/: gt_init_screen_1.c gt_init_screen_10.c gt_init_screen_11.c gt_init_screen_2.c gt_init_screen_3.c gt_init_screen_4.c gt_init_screen_5.c gt_init_screen_6.c gt_init_screen_7.c gt_init_screen_8.c gt_init_screen_9.c gt_init_screen_home.c gt_ui.c
